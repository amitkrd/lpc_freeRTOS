# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: .\sw\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549;.\sw\lpc_core\lpc_chip\chip_common;.\sw\lpc_core\lpc_chip\chip_15xx;.\sw\lpc_core\lpc_chip\chip_15xx\config_15xx;.\sw\CMSIS;.\FreeRTOSV8.2.3\FreeRTOSV8.2.3\FreeRTOS\Source\include;.\FreeRTOSV8.2.3\FreeRTOSV8.2.3\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\sw\lpc_core\lpc_board\board_common;..\lpc_FreeRTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group Source Group 1
    ./: main.c
    ./sw/startup_code/: keil_startup_lpc15xx.s sysinit.c
  group lib
    ./lib/: board_nxp_lpcxpresso_1549.lib chip_15xx_lib.lib
  group freeRTOS
    ./FreeRTOSV8.2.3/FreeRTOSV8.2.3/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOSV8.2.3/FreeRTOSV8.2.3/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ./FreeRTOSV8.2.3/FreeRTOSV8.2.3/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./sw/freertoslpc/: FreeRTOSCommonHooks.c
software components: CMSIS:CORE 4.3.0
